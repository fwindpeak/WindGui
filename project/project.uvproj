# Keil uVision project project.uvproj, settings and files
target wdgui-stm32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wdgui-stm32
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\drivers;..\stm32lib;..\stm32lib\startup;..\system;..\user
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group stm32lib
    ../stm32lib/: system_stm32f10x.c stm32f10x_fsmc.c misc.c core_cm3.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_rcc.c
    ../stm32lib/startup/: startup_stm32f10x_hd.s
  group drivers
    ../drivers/: fonts.c lcd_driver.c led.c spi.c touch.c WindGUI.c
  group user
    ../user/: main.c
  group system
    ../system/: stm32f10x_it.c stm32f10x_conf.h
